# Keil uVision project BH-F103.uvprojx, settings and files
target LVGL (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32-lvgl +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\User;..\Libraries\FWlib\inc;..\User\lvgl;..\User\lvgl\examples\porting;..\User\lvgl\demos\widgets;..\User\lvgl\examples\anim;..\User\lvgl\examples\widgets;..\User\lvgl\src\extra\widgets\animimg;..\User\lvgl\examples\event;..\User\lvgl\user;..\User\lvgl\examples\layouts\flex
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c core_cm3.h stm32f10x.h system_stm32f10x.h
  group FWLB
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c palette.c stm32f10x_it.c
    ../User/usart/: bsp_usart.c
    ../User/lcd/: bsp_ili9341_lcd.c bsp_xpt2046_lcd.c
    ../User/font/: fonts.c
    ../User/flash/: bsp_spi_flash.c
    ../User/led/: bsp_led.c
  group DOC
    ../Doc/: readme.txt
  group LVGL/CORE
    ../User/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group LVGL/DRAW
    ../User/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../User/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../User/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group LVGL/EXTRA
    ../User/lvgl/src/extra/: lv_extra.c
    ../User/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../User/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../User/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../User/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../User/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../User/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../User/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../User/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../User/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../User/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../User/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../User/lvgl/src/extra/widgets/led/: lv_led.c
    ../User/lvgl/src/extra/widgets/list/: lv_list.c
    ../User/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../User/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../User/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../User/lvgl/src/extra/widgets/span/: lv_span.c
    ../User/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../User/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../User/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../User/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../User/lvgl/src/extra/widgets/win/: lv_win.c
    ../User/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../User/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
  group LVGL/FONT
    ../User/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group LVGL/HAL
    ../User/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group LVGL/MISC
    ../User/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group LVGL/WIDGETS
    ../User/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL
    ../User/lvgl/: timer.c
    ../User/: lv_conf.h
  group LVGL/PORTING
    ../User/lvgl/examples/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group LVGL/DEMOS
    ../User/lvgl/demos/widgets/: lv_demo_widgets.c
    ../User/lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
  group LVGL/EXAM
    ../User/lvgl/examples/anim/: lv_example_anim_1.c lv_example_anim_2.c lv_example_anim_3.c lv_example_anim_timeline_1.c
  group LVGL/EXAM/ASS
    ../User/lvgl/examples/assets/: animimg001.c animimg002.c animimg003.c img_caret_down.c img_cogwheel_alpha16.c img_cogwheel_argb.c img_cogwheel_chroma_keyed.c img_cogwheel_indexed16.c img_cogwheel_rgb.c img_hand.c img_skew_strip.c img_star.c imgbtn_left.c imgbtn_mid.c imgbtn_right.c
    ../User/lvgl/examples/widgets/animimg/: lv_example_animimg_1.c
  group LVGL/EXAM/EVE
    ../User/lvgl/examples/event/: lv_example_event_1.c lv_example_event_2.c lv_example_event_3.c
  group LVGL/EXAM/LAY
    ../User/lvgl/examples/layouts/flex/: lv_example_flex_1.c lv_example_flex_2.c lv_example_flex_3.c lv_example_flex_4.c lv_example_flex_5.c lv_example_flex_6.c
  group LVGL/EX/WIN
    ../User/lvgl/examples/widgets/win/: lv_example_win_1.c
  group LVGL/EX/LA
    ../User/lvgl/examples/widgets/label/: lv_example_label_1.c lv_example_label_2.c lv_example_label_3.c lv_example_label_4.c
  group LVGL/EX/ME
    ../User/lvgl/examples/widgets/meter/: lv_example_meter_1.c lv_example_meter_2.c lv_example_meter_3.c lv_example_meter_4.c
  group LVGL/USER
    ../User/lvgl/user/: test1.c
  group LVGL/EX/BA
    ../User/lvgl/examples/widgets/bar/: lv_example_bar_1.c lv_example_bar_2.c lv_example_bar_3.c lv_example_bar_4.c lv_example_bar_5.c lv_example_bar_6.c
  group LVGL/EX/BT
    ../User/lvgl/examples/widgets/btn/: lv_example_btn_1.c lv_example_btn_2.c lv_example_btn_3.c
    ../User/lvgl/examples/widgets/btnmatrix/: lv_example_btnmatrix_1.c lv_example_btnmatrix_2.c lv_example_btnmatrix_3.c
